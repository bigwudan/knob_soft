# Keil uVision project ugui_data.uvprojx, settings and files
target data (6090000::V6.9::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ugui_data
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: ..\app\src\;..\app\src\apps\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\spiflash_data.sct
  group appkit
    ./: ui_data.c
