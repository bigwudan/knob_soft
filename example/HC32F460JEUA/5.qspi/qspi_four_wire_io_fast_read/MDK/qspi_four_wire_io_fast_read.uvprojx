# Keil uVision project qspi_four_wire_io_fast_read.uvprojx, settings and files
target qspi_four_wire_io_fast_read_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.9
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qspi_four_wire_io_fast_read
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\..\mcu\common;..\source;..\..\..\..\..\driver\inc;..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460.s
    ../../../../../mcu/common/: system_hc32f460.c
  group source
    ../source/: main.c
  group driver
    ../../../../../driver/src/: hc32f460_pwc.c hc32f460_efm.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_utility.c hc32f460_exint_nmi_swi.c hc32f460_sram.c hc32f460_qspi.c hc32f460_keyscan.c hc32f460_clk.c hc32f460_gpio.c
  group ev_hc32f460_lqfp100_v2
    ../../../../../bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group Readme
    ../: Readme.txt
target qspi_four_wire_io_fast_read_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.9
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qspi_four_wire_io_fast_read +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\..\mcu\common;..\source;..\..\..\..\..\driver\inc;..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.5.0
