# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\W25Q;..\HARDWARE\USART;..\ucgui\Config;..\ucgui\GUI\Core;..\ucgui\GUI\LCDDriver
  memory RVCT1: ROM 0xc0000000 size 0x400000
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c test.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd_init.c lcd.c
    ../HARDWARE/USART/: USART_1.C
    ../HARDWARE/W25Q/: W25QXX.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group ucgui
    ../ucgui/GUI/LCDDriver/: LCDDummy.c
  group gui_core
    ../ucgui/GUI/Core/: GUI_SetColorIndex.c GUICore.c GUI_DrawHLine.c LCD.c GUI_UC_EncodeNone.c LCD_L0_Generic.c LCDColor.c GUI_SetColor.c GUI_Goto.c GUI_DispStringAt.c GUI_DispString.c GUIChar.c GUI_UC.c GUICharLine.c GUI_RectsIntersect.c GUI_SetFont.c GUICharP.c GUI_GetColor.c LCD_GetColorIndex.c LCD_GetEx.c GUI_DrawBitmap.c GUI_SetDrawMode.c LCDPM565_Index2Color.c GUI_Pen.c GUI_DrawLine.c GUI_FillPolygon.c GUI_DrawPoint.c GUI2DLib.c LCD_DrawVLine.c GUICirc.c LCD_DrawBitmap_M565.c GUI_DispChar.c GUIArc.c GUIEncJS.c
    ../ucgui/GUI/Font/: F08_ASCII.c
    ../ucgui/GUI/ConvertColor/: LCDPM565.c
  group ui_font
    ../ucgui/GUI/Font/: F13_1.c F13_ASCII.c F32_ASCII.c FTest.c
