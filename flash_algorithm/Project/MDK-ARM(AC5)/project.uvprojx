# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ARMFLY_STM32H743_SPI_W25Q64 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH_MEM,USE_STDPERIPH_DRIVER
  c include: ..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\Libraries\SYSTEM\sys;..\..\Libraries\SYSTEM\delay;..\..\Libraries\STM32F10x_FWLib\inc;..\..\Libraries\STM32F10x_FWLib\src;..\..\Libraries\CORE;..\..\Libraries\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../../User/: FlashPrg.c
  group Device Description
    ../../User/: FlashDev.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h
    ../../User/bsp/src/: bsp_spi_bus.c bsp_spi_flash.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group SYSTEM
    ../../Libraries/SYSTEM/delay/: delay.c
    ../../Libraries/SYSTEM/sys/: sys.c
  group FWlib
    ../../Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
  group USER
    ../../Libraries/USER/: system_stm32f10x.c
