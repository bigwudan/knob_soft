# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM221xB Synwit
  pack: Synwit.SWM32_DFP.2.1.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ARMFLY_STM32H743_SPI_W25Q64 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH_MEM,USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\Libraries\CMSIS\CoreSupport;..\..\Libraries\CMSIS\SWM221_StdPeriph_Driver;..\..\Libraries\CMSIS\DeviceSupport
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../../User/: FlashPrg.c
  group Device Description
    ../../User/: FlashDev.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h
    ../../User/bsp/src/: bsp_spi_bus.c bsp_spi_flash.c
  group HAL_Driver
    ../../Libraries/CMSIS/DeviceSupport/: system_SWM221.c dev_qspi_flash.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group StdPeriph_Driver
    ../../Libraries/CMSIS/SWM221_StdPeriph_Driver/: SWM221_adc.c SWM221_can.c SWM221_crc.c SWM221_div.c SWM221_dma.c SWM221_exti.c SWM221_flash.c SWM221_gpio.c SWM221_i2c.c SWM221_iofilt.c SWM221_mpu.c SWM221_port.c SWM221_pwm.c SWM221_qei.c SWM221_qspi.c SWM221_sleep.c SWM221_spi.c SWM221_timr.c SWM221_uart.c SWM221_usart.c SWM221_wdt.c
