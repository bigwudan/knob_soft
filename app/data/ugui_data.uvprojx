# Keil uVision project ugui_data.uvprojx, settings and files
target data (6090000::V6.9::.\ARMCLANG)
  device: SWM221xB Synwit
  pack: Synwit.SWM32_DFP.2.1.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ugui_data
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: ..\app\src\;..\app\src\apps\
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\spiflash_data.sct
  group appkit
    ../app/src/apps/ui_src/appkit/data/: ui_data.c
