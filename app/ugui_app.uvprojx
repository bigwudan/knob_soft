# Keil uVision project ugui_app.uvprojx, settings and files
target SWM221-Debug (6090000::V6.9::.\ARMCLANG)
  device: SWM221xB Synwit
  pack: Synwit.SWM32_DFP.2.1.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ugui_app
  BeforeMake: default_appkit.bat
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: keil-build-viewer.exe
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c include: .\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\SWM221_StdPeriph_Driver;.\src;.\src\apps;.\src\board;.\src\board\ic_driver;.\src\components\SFUD\sfud\inc;.\src\components\MultiButton;.\src\components\CherryRB;.\src\modules
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\src\apps\SWM221_link_section.sct
  group apps
    ./src/apps/: app_cfg.h main.c semihosting.c test_case.c
  group board
    ./src/board/: board.c dev_systick.c dev_uart.c dev_misc.c dev_key.c dev_sleep_stop.c dev_tp.c dev_tp_i2c.c dev_tp_port.c dev_lcd_mpu.c dev_lcd_mpu_i80.c dev_lcd_mpu_spi.c dev_lcd_mpu_qspi.c dev_lcd_mpu_port.c dev_sw_i2c.c dev_sw_spi.c dev_qspi_flash.c
  group board\ic_driver
    ./src/board/ic_driver/: tp_cst3xx.c tp_cst8xx.c tp_ftxx.c tp_gt9xx.c tp_ili2117a.c tp_tango_c32.c tp_chsc6413.c tp_chsc6540.c lcd_st7789.c lcd_ili9488.c lcd_gx9307.c lcd_gc9307.c lcd_gc9a01.c lcd_st7365.c lcd_st77916.c lcd_nv3041.c lcd_nv3023.c
  group modules
    ./src/modules/: modbus_rtu.c
  group components\SFUD
    ./src/components/SFUD/sfud/src/: sfud.c sfud_sfdp.c
    ./src/components/SFUD/sfud/inc/: sfud_cfg.h
    ./src/components/SFUD/sfud/port/: sfud_port_swm221.c sfud_port_swm221_sw_spi.c
  group components\MultiButton
    ./src/components/MultiButton/: multi_button.c
  group components\CherryRB
    ./src/components/CherryRB/: chry_ringbuffer.c
  group CSL\CMSIS
    ./src/CSL/CMSIS/DeviceSupport/: system_SWM221.c
    ./src/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM221.s
  group CSL\StdPD
    ./src/CSL/SWM221_StdPeriph_Driver/: SWM221_adc.c SWM221_can.c SWM221_crc.c SWM221_div.c SWM221_dma.c SWM221_exti.c SWM221_flash.c SWM221_gpio.c SWM221_i2c.c SWM221_iofilt.c SWM221_mpu.c SWM221_port.c SWM221_pwm.c SWM221_qei.c SWM221_qspi.c SWM221_sleep.c SWM221_spi.c SWM221_timr.c SWM221_uart.c SWM221_usart.c SWM221_wdt.c
  group libs
    ./libs/: ugui_framework.lib
  group appkit
    ./src/apps/ui_src/appkit/: app.c
  group ui_src
    ./src/apps/ui_src/: screen001.c screen002.c
target Release (6210000::V6.21::ARMCLANG)
  device: SWM166x8 Synwit
  pack: Synwit.SWM32_DFP.2.1.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ugui_app
  BeforeMake: default_appkit.bat
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: keil-build-viewer.exe
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: CHIP_SWM166
  c include: .\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\SWM166_StdPeriph_Driver;.\src;.\src\apps;.\src\board;.\src\board\ic_driver;.\src\components\SFUD\sfud\inc;.\src\components\MultiButton;.\src\components\CherryRB;.\src\modules
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\src\apps\SWM166_link_section.sct
